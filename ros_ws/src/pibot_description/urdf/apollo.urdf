Commit message: add cp4 imu module

File: ros_ws/src/pibot_description/urdf/apollo.urdf (robot description, URDF)
Before this commit: robot pibot_description, 3 links, 2 joints
Joints:
- joint laser_link_joint: origin xyz=0 0 0.09 rpy=0 0 0 -> xyz=0 0 0.09 rpy=0 0 3.1415
